# Keil uVision project frackstock.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F031F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: frackstock
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c led.c sc.c usart.c rfm.c animation.c accel.c
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, Device:Startup 1.5.0
